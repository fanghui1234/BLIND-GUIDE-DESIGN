# Keil uVision project BLIND GUIDE.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BLIND GUIDE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\ESP8266;..\HARDWARE\HONGWAI;..\HARDWARE\JQ8400;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\LIGHT;..\HARDWARE\OLED;..\HARDWARE\TIMER;..\HARDWARE\WAVE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/HONGWAI/: HW.c
    ../HARDWARE/JQ8400/: jq8400.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LIGHT/: light.c
    ../HARDWARE/OLED/: oled_iic.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/WAVE/: wave.c
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
